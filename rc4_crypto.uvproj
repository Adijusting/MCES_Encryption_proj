# Keil uVision project rc4_crypto.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC2148 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: rc4_crypto
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Source Group 1
    ./: rc4.s
  group Core
    C:/Keil/ARM/Startup/Philips/: Startup.s
    ./: main.c
  group Drivers
    ./: uart.h uart.c timer.h timer.c
